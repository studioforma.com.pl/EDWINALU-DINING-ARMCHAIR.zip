Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Edwin Alu-Dining armchair - ver4.ifc
Time: 2025-11-26T15:08:23
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (26)
Name
 | Edwin Alu-Dining armchair_0 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_1 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_2 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_3 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_4 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_5 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_6 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_7 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_8 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_9 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_10 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_11 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_12 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_13 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_14 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_15 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_16 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_17 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_18 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_19 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_20 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_21 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_22 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_23 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_24 - ObjectType: SketchupGroup
 | Edwin Alu-Dining armchair_25 - ObjectType: SketchupGroup
